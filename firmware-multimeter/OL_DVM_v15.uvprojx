# Keil uVision project OL_DVM_v15.uvprojx, settings and files
target rev1.5 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F373CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OL_DVM_v14 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.cpp init.h init.cpp config.h interrupt.cpp interrupt.h
  group analog
    ./: sdadc.cpp sdadc.h adc.h adc.cpp
  group display
    ./lcd_5110/: 5110.cpp 5110.h
    ./: draw.cpp draw.h
  group util
    ./: delay.cpp delay.h
  group non-code
    ./: map.txt
  group uart
    ./: uart.cpp uart.h
  group eeprom
    ./: at24c.cpp at24c.h i2c.cpp i2c.h
  group ctest
    ./: ctest.cpp ctest.h
software components: CMSIS:CORE 5.0.0, Device:Startup 1.3.0
