# Keil uVision project OL_DVM_v12.uvprojx, settings and files
target V12 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OL_DVM_v12
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: main.cpp init.cpp init.h delay.cpp delay.h defines.h interrupt.cpp interrupt.h ctest.cpp ctest.h uart.h uart.cpp
  group display
    ./lcd_5110/: 5110.cpp 5110.h
    ./: draw.cpp draw.h
  group non-code
    ./: map.txt
  group analog
    ./: adc.cpp adc.h adc_interrupt.cpp adc_interrupt.h
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
